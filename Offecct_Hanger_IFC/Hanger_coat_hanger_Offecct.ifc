Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: hanger_cloth_hanger.ifc
Time: 2017-02-21T08:50:57
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Hanger, cloth hanger
ePset_BIMobject_Lena - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Hanger, cloth hanger; SKU (BO_prodsku): Hanger; ManufacturName (BO_Manufac): Offecct; BrandUrl (BO_brandurl): http://www.offecct.se; EditionNumber (BO_edinum): 1; Width (BO_width): 400; Height (BO_height): 1800; Depth (BO_depth): 265; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/offecct/product/Hanger; ProductDataUrl (BO_prodaturl): bimobject.com/offecct/product/Hanger; IfcClassification (BO_ifcclas): Furniture; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
